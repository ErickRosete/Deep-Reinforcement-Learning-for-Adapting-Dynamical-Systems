Commit message: Updated SAC Agent + Tactile Sensor

File: env/robots/sawyer_wsg50.urdf (robot description, URDF)
Before this commit: robot sawyer, 26 links, 25 joints
Links:
- link head_camera: mass None -> 1e-08
- link right_hand_camera: mass None -> 1e-08
- link right_wrist: mass None -> 1e-08
